# Keil uVision project MPU TEST.uvprojx, settings and files
target MPU TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: MPU TEST +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,MPU9250,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,EMPL_TARGET_STM32F4
  c include: ../Inc;  ..\..\DMP_Lib\driver\eMPL;  ..\..\DMP_Lib\driver\include;  ..\..\DMP_Lib\driver\stm32L;  ..\..\DMP_Lib\eMPL-hal;  ..\..\DMP_Lib\mllite;  ..\..\DMP_Lib\mpl;  ..\MDK-ARM; C:/Users/DELL/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.0/Drivers/STM32F4xx_HAL_Driver/Inc; C:/Users/DELL/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; C:/Users/DELL/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include; C:/Users/DELL/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User
    ./: arch.c board_resource.c
    ../Src/: main.c gpio.c i2c.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group DMP_Lib/driver/eMPL
    ../../DMP_Lib/driver/eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group DMP_Lib/driver/include
    ../../DMP_Lib/driver/include/: log.h mlinclude.h mlmath.h mlos.h mltypes.h mpu.h stdint_invensense.h
  group DMP_Lib/driver/stm32L
    ../../DMP_Lib/driver/stm32L/: log_stm32.c packet.h
  group DMP_Lib/eMPL-hal
    ../../DMP_Lib/eMPL-hal/: eMPL_outputs.c eMPL_outputs.h
  group DMP_Lib/mllite
    ../../DMP_Lib/mllite/: data_builder.c data_builder.h hal_outputs.c hal_outputs.h invensense.h message_layer.c message_layer.h ml_math_func.c ml_math_func.h mlmath.c mpl.c mpl.h results_holder.c results_holder.h start_manager.c start_manager.h storage_manager.c storage_manager.h
  group DMP_Lib/mpl
    ../../DMP_Lib/mpl/: accel_auto_cal.h compass_vec_cal.h fast_no_motion.h fusion_9axis.h gyro_tc.h heading_from_gyro.h inv_math.h invensense_adv.h libmpllib.lib mag_disturb.h motion_no_motion.h no_gyro_fusion.h quaternion_supervisor.h
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/DELL/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
software components: CMSIS:CORE 4.3.0
